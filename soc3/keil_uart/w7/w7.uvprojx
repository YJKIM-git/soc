# Keil uVision project w7.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: w7
  AfterMake: fromelf --vhx --32x1 --output=code.mem ./Objects/w7.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\common\include;..\..\common\cmsis
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\scatter.sct
  group Source Group 1
    ../../common/include/: hy_soc.h
    ../../common/cmsis/: core_cm0.h core_cmFunc.h core_cmInstr.h
    ../: test.c startup_cm0_w7.S
